# Keil uVision project mcuio.uvproj, settings and files
target 对象 1 (MCS-51)
  device: (null) (null)
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: mcuio
  c flags: Optimize=8 SizeSpeed=1
  group 源文件组 1
    ./: mcuIO.asm
